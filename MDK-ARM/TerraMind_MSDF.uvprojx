# Keil uVision project TerraMind_MSDF.uvprojx, settings and files
target TerraMind_MSDF (6210000::V6.21::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: TerraMind_MSDF +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=9 wLevel=1
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../TerraMind_FW/Navigation/core;../KF-GINS/ThirdParty/eigen-3.3.9;../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/ST/STM32_MotionAC_Library/Inc;../Middlewares/ST/STM32_MotionAW_Library/Inc;../Middlewares/ST/STM32_MotionEC_Library/Inc;../Middlewares/ST/STM32_MotionFX_Library/Inc;../Middlewares/ST/STM32_MotionGC_Library/Inc;../Middlewares/ST/STM32_MotionID_Library/Inc;../Middlewares/ST/STM32_MotionMC_Library/Inc;../Middlewares/ST/STM32_MotionPM_Library/Inc;../Middlewares/ST/STM32_MotionPW_Library/Inc;../Middlewares/ST/STM32_MotionTL_Library/Inc;../Middlewares/ST/ARM/DSP/Inc
  asm include: ../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group TerraMind_FW/App
    ../TerraMind_FW/App/: app_tasks.cpp app_tasks.h app_main.cpp gyro_bias_calibration.cpp gyro_bias_calibration.h app_main.h um982_app.cpp um982_app.h monitor_app.cpp monitor_app.h
  group TerraMind_FW/BSP
    ../TerraMind_FW/BSP/: imu_uart_bsp.cpp imu_uart_bsp.h um982_uart_bsp.cpp um982_uart_bsp.h uart_rx_callbacks.cpp monitor_uart6_dma.cpp monitor_uart6_dma.h time_sync_capture.c time_sync_capture.h
  group TerraMind_FW/Driver
    ../TerraMind_FW/Driver/: g365_imu.cpp g365_imu.h um982_parser.cpp um982_parser.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Navigation (live 200 Hz / output 100 Hz)
    ../TerraMind_FW/Navigation/: nav_output_protocol.cpp navigation_live.cpp navigation.cpp navigation.h
    ../TerraMind_FW/BSP/: navigation_uart_dma.cpp
    ../TerraMind_FW/App/: app_navigation.cpp
    ../TerraMind_FW/Navigation/core/kf-gins/: gi_engine.cpp insmech.cpp
software components: CMSIS:CORE 6.1.1
